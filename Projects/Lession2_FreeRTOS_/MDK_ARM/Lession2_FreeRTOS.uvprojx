# Keil uVision project Lession2_FreeRTOS.uvprojx, settings and files
target Lession2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Lession1_HelloWord +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32746G_DISCOVERY,USE_FULL_ASSERT
  c misc: --C99
  c include: ..\Inc;..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32746G-Discovery;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Lession2/Main
    ../Src/: main.c startup_stm32f746xx.s stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Lession2/Driver
    ../Src/: uart.c error.c retarget.c
  group Doc
    ../: Readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_uart.c stm32f7xx_hal_gpio.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/STM32746G-Discovery
    ../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMIS_RTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middleware /FreeRTOS/portable
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.1.2
